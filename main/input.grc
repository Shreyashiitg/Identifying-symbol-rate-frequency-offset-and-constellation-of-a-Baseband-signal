options:
  parameters:
    author: Shreyash Bharati
    generate_options: qt_gui
    id: input_file
    output_language: python
    title: input file
  states: {}

blocks:
- name: d
  id: variable
  parameters:
    value: '128'
  states: {}
- name: i
  id: variable
  parameters:
    value: '125'
  states: {}
- name: nsamp
  id: variable
  parameters:
    value: samp_rate*i/d
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4096000'
  states: {}
- name: blocks_exponentiate_const_cci_0
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '8'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Downloads\IIT ECE studies\6th sem\EE 332 Digital Communications\Assignment\Assignment 2\file-iq\file86.iq
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '5'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: nsamp
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: nsamp
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: nsamp
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 6.28/100
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    name: Before Resampling
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: nsamp
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    name: After Resampling
    type: complex
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: nsamp
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    name: Frequency Offset
    type: complex
    wintype: window.WIN_KAISER
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: d
    interp: i
    type: ccc
  states: {}

connections:
- [blocks_exponentiate_const_cci_0, '0', blocks_throttle2_0_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_0_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_throttle2_0_0_0_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_throttle2_0_0_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_exponentiate_const_cci_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [rational_resampler_xxx_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
